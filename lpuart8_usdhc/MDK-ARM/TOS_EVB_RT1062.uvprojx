# Keil uVision project TOS_EVB_RT1062.uvprojx, settings and files
target ram_debug (6140000::V6.14::ARMCLANG)
  device: MIMXRT1062CVL5A NXP
  pack: NXP.MIMXRT1062_DFP.13.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: TOS_EVB_RT1062
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_MIMXRT1062DVL6A,NDEBUG
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..\..\SDK\devices\MIMXRT1062;..\..\SDK\devices\MIMXRT1062\drivers;..\Board;..\include;..\..\SDK\CMSIS\Include;..\BSP;..\..\SDK\middleware\sdmmc\common;..\..\SDK\middleware\sdmmc\host\usdhc;..\..\SDK\middleware\sdmmc\sd;..\..\SDK\middleware\sdmmc\osa;..\..\SDK\components\osa;..\..\SDK\components\lists
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\arm\MIMXRT1062xxxxx_ram.scf
  link misc: --remove
  group startup
    ./arm/: startup_MIMXRT1062.S
  group devices
    ../../SDK/devices/MIMXRT1062/: system_MIMXRT1062.c
  group drivers
    ../../SDK/devices/MIMXRT1062/drivers/: fsl_adc.c fsl_adc_etc.c fsl_aipstz.c fsl_aoi.c fsl_bee.c fsl_cache.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_csi.c fsl_dcdc.c fsl_dcp.c fsl_dmamux.c fsl_edma.c fsl_elcdif.c fsl_enc.c fsl_enet.c fsl_ewm.c fsl_flexcan.c fsl_flexcan_edma.c fsl_flexio.c fsl_flexio_camera.c fsl_flexio_camera_edma.c fsl_flexio_i2c_master.c fsl_flexio_i2s.c fsl_flexio_i2s_edma.c fsl_flexio_mculcd.c fsl_flexio_mculcd_edma.c fsl_flexio_spi.c fsl_flexio_spi_edma.c fsl_flexio_uart.c fsl_flexio_uart_edma.c fsl_flexram.c fsl_flexram_allocate.c fsl_flexspi.c fsl_flexspi_edma.c fsl_gpc.c fsl_gpio.c fsl_gpt.c fsl_kpp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lpuart.c fsl_lpuart_edma.c fsl_ocotp.c fsl_pit.c fsl_pmu.c fsl_pwm.c fsl_pxp.c fsl_qtmr.c fsl_romapi.c fsl_rtwdog.c fsl_sai.c fsl_sai_edma.c fsl_semc.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_spdif.c fsl_spdif_edma.c fsl_src.c fsl_tempmon.c fsl_trng.c fsl_tsc.c fsl_usdhc.c fsl_wdog.c fsl_xbara.c fsl_xbarb.c
  group bsp
    ../BSP/: bsp_led.c bsp_lpuart.c bsp_usdhc.c
  group board
    ../Board/: board.c clock_config.c pin_mux.c
  group source
    ../source/: main.c
  group middleware/sdmmc
    ../../SDK/middleware/sdmmc/common/: fsl_sdmmc_common.c
    ../../SDK/middleware/sdmmc/host/usdhc/blocking/: fsl_sdmmc_host.c
    ../../SDK/middleware/sdmmc/sd/: fsl_sd.c
    ../../SDK/middleware/sdmmc/osa/: fsl_sdmmc_osa.c
  group components/osa
    ../../SDK/components/osa/: fsl_os_abstraction_bm.c
  group components/lists
    ../../SDK/components/lists/: fsl_component_generic_list.c
