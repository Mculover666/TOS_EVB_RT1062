# Keil uVision project TOS_EVB_RT1062.uvprojx, settings and files
target ram_debug (6140000::V6.14::ARMCLANG)
  device: MIMXRT1062CVL5A NXP
  pack: NXP.MIMXRT1062_DFP.13.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: TOS_EVB_RT1062
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1062xxxxx_ram.scf
  group Startup
    ./: startup_MIMXRT1062.S
  group Src
    ../Src/: main.c
