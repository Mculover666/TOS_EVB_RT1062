# Keil uVision project TOS_EVB_RT1062.uvprojx, settings and files
target ram_debug (6140000::V6.14::ARMCLANG)
  device: MIMXRT1062CVL5A NXP
  pack: NXP.MIMXRT1062_DFP.13.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: TOS_EVB_RT1062
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_MIMXRT1062DVL6A,NDEBUG
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..\..\SDK\devices\MIMXRT1062;..\..\SDK\devices\MIMXRT1062\drivers;..\Board;..\include;..\..\SDK\CMSIS\Include;..\BSP
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x200000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\arm\MIMXRT1062xxxxx_ram.scf
  link misc: --remove
  group startup
    ./arm/: startup_MIMXRT1062.S
  group devices
    ../../SDK/devices/MIMXRT1062/: system_MIMXRT1062.c
  group drivers
    ../../SDK/devices/MIMXRT1062/drivers/: fsl_cache.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_dcdc.c fsl_dcp.c fsl_elcdif.c fsl_gpc.c fsl_gpio.c fsl_gpt.c fsl_kpp.c fsl_lpuart.c fsl_src.c fsl_tempmon.c fsl_trng.c fsl_tsc.c fsl_wdog.c
  group bsp
    ../BSP/: bsp_led.c bsp_lpuart.c bsp_elcdif.c
  group board
    ../Board/: board.c clock_config.c pin_mux.c
  group source
    ../source/: main.c
